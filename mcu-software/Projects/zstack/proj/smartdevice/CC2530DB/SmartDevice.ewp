# IAR project SmartDevice.ewp, settings and files
configuration Debug (8051, debug)
  General.OGChipSelectMenu: CC2530F256 CC2530F256
  ICC8051.CCDefines: NWK_AUTO_POLL; ZTOOL_P1; xMT_TASK; xMT_SYS_FUNC; xMT_ZDO_FUNC
  ICC8051.OCCDataMemoryModel: 1
  ICC8051.OCCCodeMemoryModel: 1
  ICC8051.CCIncludePath2: $PROJ_DIR$; ..\Source; ..\..\..\ZMain\TI2530DB; ..\..\..\..\..\Components\hal\include; ..\..\..\..\..\Components\hal\target\CC2530EB; ..\..\..\..\..\Components\mac\include; ..\..\..\..\..\Components\mac\high_level; ..\..\..\..\..\Components\mac\low_level\srf04; ..\..\..\..\..\Components\mac\low_level\srf04\single_chip; ..\..\..\..\..\Components\mt; ..\..\..\..\..\Components\osal\include; ..\..\..\..\..\Components\services\saddr; ..\..\..\..\..\Components\services\sdata; ..\..\..\..\..\Components\stack\af; ..\..\..\..\..\Components\stack\nwk; ..\..\..\..\..\Components\stack\sapi; ..\..\..\..\..\Components\stack\sec; ..\..\..\..\..\Components\stack\sys; ..\..\..\..\..\Components\stack\zdo; ..\..\..\..\..\Components\zmac; ..\..\..\..\..\Components\zmac\f8w
  ICC8051.CCOptLevel: 1
  ICC8051.CCOptStrategy: 0
  ICC8051.IccLang: 0
  XLINK.XclFile: $TOOLKIT_DIR$\config\devices\Texas Instruments\lnk51ew_CC2530F256_banked.xcl
configuration Release (8051)
  as the first configuration, except:
  General.RTConfigPath: xxx.h
  General.OGChipSelectMenu: 8052 Generic 8052
  ICC8051.CCDefines: NDEBUG
  ICC8051.CCOptLevel: 3
  A8051.ADefines: NDEBUG
  XLINK.XclFile: lnk0t.xcl
configuration DemoEB (8051, debug)
  as the first configuration, except:
  General.RTConfigPath: xxx.h
  General.OGChipSelectMenu: 8052 Generic 8052
  XLINK.XclFile: lnk0t.xcl
configuration CoordinatorEB (8051, debug)
  as the first configuration, except:
  ICC8051.CCDefines: ZTOOL_P1; xMT_TASK; xMT_SYS_FUNC; xMT_ZDO_FUNC
  ICC8051.CCDiagSuppress: Pe001,Pa010
  ICC8051.CCIncludePath2: $PROJ_DIR$; ..\Source; ..\..\..\ZMain\TI2530DB; ..\..\..\..\..\Components\hal\include; ..\..\..\..\..\Components\hal\target\CC2530EB; ..\..\..\..\..\Components\mac\include; ..\..\..\..\..\Components\mac\high_level; ..\..\..\..\..\Components\mac\low_level\srf04; ..\..\..\..\..\Components\mac\low_level\srf04\single_chip; ..\..\..\..\..\Components\mt; ..\..\..\..\..\Components\osal\include; ..\..\..\..\..\Components\services\saddr; ..\..\..\..\..\Components\services\sdata; ..\..\..\..\..\Components\stack\af; ..\..\..\..\..\Components\stack\nwk; ..\..\..\..\..\Components\stack\sapi; ..\..\..\..\..\Components\stack\sec; ..\..\..\..\..\Components\stack\sys; ..\..\..\..\..\Components\stack\zdo; ..\..\..\..\..\Components\zmac; ..\..\..\..\..\Components\zmac\f8w; ..\Source\app; ..\Source\bsp; ..\Source\devicelist; ..\Source\gizwits; ..\Source\hal; ..\Source\myprotocol
  ICC8051.CCOptLevel: 3
  XLINK.XclFile: ..\..\..\Tools\CC2530DB\f8w2530.xcl
configuration RouterEB (8051, debug)
  as the first configuration, except:
  ICC8051.CCDefines: NWK_AUTO_POLL; ZTOOL_P1; MT_TASK; MT_SYS_FUNC; MT_ZDO_FUNC
  ICC8051.CCDiagSuppress: Pe001,Pa010,Pa050
  ICC8051.CCIncludePath2: as above
  XLINK.XclFile: ..\..\..\Tools\CC2530DB\f8w2530.xcl
configuration EndDeviceEB (8051, debug)
  as the first configuration, except:
  ICC8051.CCDiagSuppress: Pe001,Pa010,Pa050
  ICC8051.CCIncludePath2: as above
  ICC8051.CCOptLevel: 0
  XLINK.XclFile: ..\..\..\Tools\CC2530DB\f8w2530.xcl
configuration IOT_DEVICE_CURTAIN (8051, debug)
  as the first configuration, except:
  ICC8051.CCDefines: NWK_AUTO_POLL; ZTOOL_P1; xMT_TASK; xMT_SYS_FUNC; xMT_ZDO_FUNC; MYIOT_DEVICE_CURTAIN
  ICC8051.CCDiagSuppress: Pe001,Pa010,Pa050
  ICC8051.CCIncludePath2: as above
  ICC8051.CCOptLevel: 0
  XLINK.XclFile: ..\..\..\Tools\CC2530DB\f8w2530.xcl
configuration IOT_DEVICE_HT_SENSOR (8051, debug)
  as the first configuration, except:
  ICC8051.CCDefines: NWK_AUTO_POLL; ZTOOL_P1; xMT_TASK; xMT_SYS_FUNC; xMT_ZDO_FUNC; MYIOT_DEVICE_HT_SENSOR
  ICC8051.CCDiagSuppress: Pe001,Pa010,Pa050
  ICC8051.CCIncludePath2: as above
  ICC8051.CCOptLevel: 0
  XLINK.XclFile: ..\..\..\Tools\CC2530DB\f8w2530.xcl
configuration IOT_DEVICE_LIGHT (8051, debug)
  as the first configuration, except:
  ICC8051.CCDefines: NWK_AUTO_POLL; ZTOOL_P1; xMT_TASK; xMT_SYS_FUNC; xMT_ZDO_FUNC; MYIOT_DEVICE_LIGHT
  ICC8051.CCDiagSuppress: Pe001,Pa010,Pa050
  ICC8051.CCIncludePath2: as above
  ICC8051.CCOptLevel: 0
  XLINK.XclFile: ..\..\..\Tools\CC2530DB\f8w2530.xcl
configuration IOT_DEVICE_SOCKET (8051, debug)
  as the first configuration, except:
  ICC8051.CCDefines: NWK_AUTO_POLL; ZTOOL_P1; xMT_TASK; xMT_SYS_FUNC; xMT_ZDO_FUNC; MYIOT_DEVICE_SOCKET
  ICC8051.CCDiagSuppress: Pe001,Pa010,Pa050
  ICC8051.CCIncludePath2: as above
  ICC8051.CCOptLevel: 0
  XLINK.XclFile: ..\..\..\Tools\CC2530DB\f8w2530.xcl
configuration IOT_DEVICE_COORD (8051, debug)
  as the first configuration, except:
  ICC8051.CCDefines: ZTOOL_P1; xMT_TASK; xMT_SYS_FUNC; xMT_ZDO_FUNC; MYIOT_DEVICE_COORD
  ICC8051.CCDiagSuppress: Pe001,Pa010,Pa050
  ICC8051.CCIncludePath2: as above
  ICC8051.CCOptLevel: 0
  XLINK.XclFile: ..\..\..\Tools\CC2530DB\f8w2530.xcl
configuration IOT_DEVICE_LIGHT_ROUTER (8051, debug)
  as the first configuration, except:
  ICC8051.CCDefines: as above
  ICC8051.CCDiagSuppress: Pe001,Pa010,Pa050
  ICC8051.CCIncludePath2: as above
  XLINK.XclFile: ..\..\..\Tools\CC2530DB\f8w2530.xcl
  group App
    ../Source/app/: OSAL_Init.c
  group App/app
    ../Source/app/: app_save.c app_save.h app_time.c app_time.h app_timer.c app_timer.h
  group App/bsp
    ../Source/bsp/: bsp_coord.c bsp_coord.h bsp_curtain.c bsp_curtain.h bsp_htsensor.c bsp_htsensor.h bsp_key.c bsp_key.h bsp_light.c bsp_light.h bsp_socket.c bsp_socket.h
  group App/DeviceList
    ../Source/devicelist/: devicelist.c devicelist.h mynode.c mynode.h
  group App/Gizwits
    ../Source/gizwits/: gizwits_product.c gizwits_product.h gizwits_protocol.c gizwits_protocol.h
  group App/hal
    ../Source/hal/: hal_dht11.c hal_dht11.h hal_ds1302.c hal_ds1302.h mcu_adc.c mcu_adc.h mcu_timer.c mcu_timer.h
  group App/myiot
    ../Source/app/: myiot.c myiot.h
  group App/MyProtocol
    ../Source/myprotocol/: myprotocol.c myprotocol.h
  group HAL/Common
    ../../../../../Components/hal/common/: hal_assert.c hal_drivers.c
  group HAL/Include
    ../../../../../Components/hal/include/: hal_adc.h hal_assert.h hal_board.h hal_ccm.h hal_defs.h hal_drivers.h hal_flash.h hal_key.h hal_led.h hal_sleep.h hal_timer.h hal_uart.h
  group HAL/Target/CC2530EB/Config
    ../../../../../Components/hal/target/CC2530EB/: hal_board_cfg.h
  group HAL/Target/CC2530EB/Drivers
    ../../../../../Components/hal/target/CC2530EB/: hal_adc.c hal_dma.c hal_flash.c hal_key.c hal_led.c hal_sleep.c hal_startup.c hal_timer.c hal_uart.c
  group HAL/Target/CC2530EB/Includes
    ../../../../../Components/hal/target/CC2530EB/: hal_aes.h hal_dma.h hal_mcu.h hal_types.h
  group MAC/High Level
    ../../../../../Components/mac/high_level/: mac_cfg.c mac_high_level.h mac_pib.c mac_pib.h mac_spec.h
  group MAC/Include
    ../../../../../Components/mac/include/: mac_api.h
  group MAC/Low Level/Common
    ../../../../../Components/mac/low_level/srf04/: mac_assert.h mac_autopend.c mac_autopend.h mac_backoff_timer.c mac_backoff_timer.h mac_low_level.c mac_low_level.h mac_radio.c mac_radio.h mac_rx.c mac_rx.h mac_rx_onoff.c mac_rx_onoff.h mac_sleep.c mac_sleep.h mac_tx.c mac_tx.h
  group MAC/Low Level/System
    ../../../../../Components/mac/low_level/srf04/single_chip/: mac_csp_tx.c mac_csp_tx.h mac_mcu.c mac_mcu.h mac_mem.c mac_mem.h mac_radio_defs.c mac_radio_defs.h mac_rffrontend.c
  group MT
    ../../../../../Components/mt/: DebugTrace.c DebugTrace.h MT.c MT.h MT_AF.c MT_AF.h MT_APP.c MT_APP.h MT_DEBUG.c MT_DEBUG.h MT_NWK.c MT_NWK.h MT_RPC.h MT_SAPI.c MT_SAPI.h MT_SYS.c MT_SYS.h MT_TASK.c MT_TASK.h MT_UART.c MT_UART.h MT_UTIL.c MT_UTIL.h MT_VERSION.c MT_VERSION.h MT_ZDO.c MT_ZDO.h
  group NWK
    ../../../../../Components/stack/nwk/: AddrMgr.h APS.h aps_frag.h aps_groups.h aps_util.h APSMEDE.h AssocList.h BindingTable.c BindingTable.h NLMEDE.h nwk.h nwk_bufs.h nwk_globals.c nwk_globals.h nwk_util.h reflecttrack.h rtg.h stub_aps.c stub_aps.h
    ../../../../../Components/stack/sys/: ZGlobals.c ZGlobals.h
  group OSAL
    ../../../../../Components/osal/include/: comdef.h OSAL.h OSAL_Clock.h OSAL_Memory.h OSAL_Nv.h OSAL_PwrMgr.h OSAL_Tasks.h OSAL_Timers.h ZComDef.h
    ../../../../../Components/osal/common/: OSAL.c OSAL_Clock.c OSAL_Memory.c OSAL_PwrMgr.c OSAL_Timers.c
    ../../../../../Components/osal/mcu/cc2530/: OSAL_Math.s51 OSAL_Nv.c
  group Profile
    ../../../../../Components/stack/af/: AF.c AF.h
  group Security
    ../../../../../Components/stack/sec/: ssp.h ssp_hash.h
  group Services
    ../../../../../Components/services/saddr/: saddr.c saddr.h
  group Tools
    ../../../Tools/CC2530DB/: f8w2530.xcl f8wConfig.cfg f8wCoord.cfg f8wEndev.cfg f8wRouter.cfg
  group ZDO
    ../../../../../Components/stack/zdo/: ZDApp.c ZDApp.h ZDConfig.c ZDConfig.h ZDNwkMgr.c ZDNwkMgr.h ZDObject.c ZDObject.h ZDProfile.c ZDProfile.h ZDSecMgr.c ZDSecMgr.h
  group ZMac
    ../../../../../Components/zmac/f8w/: zmac.c zmac_cb.c zmac_internal.h
    ../../../../../Components/zmac/: ZMAC.h
  group ZMain
    ../../../ZMain/TI2530DB/: chipcon_cstartup.s51 OnBoard.c OnBoard.h ZMain.c
